# IAR project dsp_fft.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: M481AE series Nuvoton M481AE series (M481AE,M482AE,M483AE,M485AE,M487AE)
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: ARM_MATH_CM4=1UL; __FPU_PRESENT=1UL
  ICCARM.CCDiagSuppress: Pa082, Pa093
  ICCARM.CCIncludePath2: ..\..\..\..\Library\Device\Nuvoton\nua3500_m4\Include; ..\..\..\..\Library\CMSIS\Include; ..\..\..\..\Library\StdDriver\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: dsp_fft.bin
  ILINK.IlinkOutputFile: dsp_fft.out
  ILINK.IlinkIcfFile: dsp_fft.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/nua3500_m4/Source/IAR/: startup_nua3500_m4.s
    ../../../../Library/Device/Nuvoton/nua3500_m4/Source/: system_nua3500_m4.c
  group Library
    ../../../../Library/CMSIS/DSP_Lib/Source/TransformFunctions/: arm_bitreversal.c arm_cfft_radix4_f32.c arm_cfft_radix4_init_f32.c
    ../../../../Library/CMSIS/DSP_Lib/Source/ComplexMathFunctions/: arm_cmplx_mag_f32.c
    ../../../../Library/CMSIS/DSP_Lib/Source/CommonTables/: arm_common_tables.c
    ../../../../Library/CMSIS/DSP_Lib/Source/StatisticsFunctions/: arm_max_f32.c
    ../../../../Library/StdDriver/src/: clk.c retarget.c sys.c uart.c
  group User
    ../: arm_fft_bin_data.c main.c
