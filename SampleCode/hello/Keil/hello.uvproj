# Keil uVision project hello.uvproj, settings and files
target Hello (ARM-ADS)
  device: Cortex-M4 FPU ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE FPU2
  output: Hello
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=3 v6Lang=1 v6LangP=1
  c include: ..\..\..\Library\CMSIS\Include;..\..\..\Library\Device\Nuvoton\NUA3500M4\Include;..\..\..\Library\StdDriver\inc
  link misc: --map --first='startup_NUA3500M4.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../Library/Device/Nuvoton/NUA3500M4/Source/: system_NUA3500M4.c
    ../../../Library/Device/Nuvoton/NUA3500M4/Source/ARM/: startup_NUA3500M4.s
  group Library
    ../../../Library/StdDriver/src/: retarget.c
  group User
    ../: main.c
