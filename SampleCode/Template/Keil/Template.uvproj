# Keil uVision project Template.uvproj, settings and files
target Template (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: M487JIDAE Nuvoton
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x9FFF) CLOCK(72000000) CPUTYPE("Cortex-M4") FPU2
  output: template
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=3 v6Lang=1 v6LangP=1
  c include: ..\..\..\Library\CMSIS\Include;..\..\..\Library\Device\Nuvoton\nua3500_m4\Include;..\..\..\Library\StdDriver\inc
  memory RVCT4: ROM 0x0 size 0xa000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --map --first='startup_nua3500_m4.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../Library/Device/Nuvoton/nua3500_m4/Source/: system_nua3500_m4.c
    ../../../Library/Device/Nuvoton/nua3500_m4/Source/ARM/: startup_nua3500_m4.s
  group Library
    ../../../Library/StdDriver/src/: retarget.c uart.c sys.c clk.c
  group User
    ../: main.c
