# IAR project Template.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: M481AE series Nuvoton M481AE series (M481AE,M482AE,M483AE,M485AE,M487AE)
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: ..\..\..\Library\CMSIS\Include; ..\..\..\Library\Device\Nuvoton\nua3500_m4\Include; ..\..\..\Library\StdDriver\inc
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Template.bin
  ILINK.IlinkOutputFile: Template.out
  ILINK.IlinkIcfFile: Template.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group CMSIS
    ../../../Library/Device/Nuvoton/nua3500_m4/Source/IAR/: startup_nua3500_m4.s
    ../../../Library/Device/Nuvoton/nua3500_m4/Source/: system_nua3500_m4.c
  group Library
    ../../../Library/StdDriver/src/: clk.c retarget.c sys.c uart.c
  group User
    ../: main.c
