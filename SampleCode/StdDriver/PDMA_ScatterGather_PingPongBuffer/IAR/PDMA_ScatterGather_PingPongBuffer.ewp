# IAR project PDMA_ScatterGather_PingPongBuffer.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: M481AE series Nuvoton M481AE series (M481AE,M482AE,M483AE,M485AE,M487AE)
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCIncludePath2: ..\..\..\..\Library\CMSIS\Include; ..\..\..\..\Library\Device\Nuvoton\nua3500_m4\Include; ..\..\..\..\Library\StdDriver\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: PDMA_ScatterGather_PingPongBuffer.bin
  ILINK.IlinkOutputFile: PDMA_ScatterGather_PingPongBuffer.out
  ILINK.IlinkIcfFile: ..\..\..\..\Script\nua3500_m4.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/nua3500_m4/Source/IAR/: startup_nua3500_m4.s
    ../../../../Library/Device/Nuvoton/nua3500_m4/Source/: system_nua3500_m4.c
  group Library
    ../../../../Library/StdDriver/src/: clk.c pdma.c retarget.c sys.c uart.c
  group User
    ../: main.c
