# Keil uVision project ECAP_GetInputFreq.uvproj, settings and files
target ECAP_GetInputFreq (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: Cortex-M4 FPU ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE FPU2
  output: ECAP_GetInputFreq
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=3 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\..\..\..\Library\Device\Nuvoton\nua3500_m4\Include;..\..\..\..\Library\CMSIS\Include;..\..\..\..\Library\StdDriver\inc
  library: MicroLIB
  link misc: --map --first='startup_nua3500_m4.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/nua3500_m4/Source/: system_nua3500_m4.c
    ../../../../Library/Device/Nuvoton/nua3500_m4/Source/ARM/: startup_nua3500_m4.s
  group User
    ../: main.c
  group Library
    ../../../../Library/StdDriver/src/: retarget.c uart.c ecap.c clk.c sys.c timer.c gpio.c
