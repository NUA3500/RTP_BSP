# Keil uVision project wdt_wwdt.uvproj, settings and files
target wdt_wwdt (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: M487JIDAE Nuvoton
  cpu: IRAM(0x20000000-0x20027FFF) IROM(0-0x7FFFF) CLOCK(192000000) CPUTYPE("Cortex-M4") FPU2
  output: wdt_wwdt
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=3 v6Lang=1 v6LangP=1
  c include: ..\..\..\Library\CMSIS\Include;..\..\..\Library\Device\Nuvoton\NUA3500M4\Include;..\..\..\Library\StdDriver\inc
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x28000
  link misc: --map --first='startup_NUA3500M4.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../Library/Device/Nuvoton/NUA3500M4/Source/: system_NUA3500M4.c
    ../../../Library/Device/Nuvoton/NUA3500M4/Source/ARM/: startup_NUA3500M4.s
  group Library
    ../../../Library/StdDriver/src/: retarget.c
  group User
    ../: main.c WDT_FunctionTest.c WDT_WWD_Main.c WDT_WWDT_RegisterTest.c WWDT_FunctionTest.c
